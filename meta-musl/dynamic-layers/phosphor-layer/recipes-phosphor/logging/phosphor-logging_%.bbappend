CXXFLAGS:append = " -Wno-error=pedantic "
