# Not supported yet
IMAGE_INSTALL:remove = "libnss-systemd"
