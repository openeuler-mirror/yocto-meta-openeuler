require rt-tests-openeuler.inc
