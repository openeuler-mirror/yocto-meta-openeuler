require libmetal.inc