PV  = "1.13.0"
OPENEULER_BRANCH = "openEuler-23.03"
SRC_URI = "file://libevdev-${PV}.tar.xz"
SRC_URI[sha256sum] = "1dbba41bc516d3ca7abc0da5b862efe3ea8a7018fa6e9b97ce9d39401b22426c"
