SRC_URI:prepend = " \
    file://${BP}.tar.gz \
    file://0001-examples-testd.c-fix-some-typos.patch \
"
