PV = "3.6"

SRC_URI = "file://${BPN}-${PV}.tar.gz"

S = "${WORKDIR}/${BPN}-${PV}"
