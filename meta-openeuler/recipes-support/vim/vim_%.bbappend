require vim-openeuler.inc
