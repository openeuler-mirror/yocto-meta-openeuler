PV = "2.38.0"

SRC_URI[archive.md5sum] = "4dcea15cbf166706c166fc4fee05e3f8"
SRC_URI[archive.sha256sum] = "ac4de2a4ef4bd5665052952fe169657e65e895c5057dffb3c2a810f6191a0c36"
