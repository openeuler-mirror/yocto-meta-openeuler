# skip null dir like:
# /usr/share/locale/be/LC_MESSAGES

INSANE_SKIP:${PN} += "installed-vs-shipped"
