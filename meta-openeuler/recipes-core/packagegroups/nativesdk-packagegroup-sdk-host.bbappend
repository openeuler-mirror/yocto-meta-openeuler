# no unfs3 src in openeuler
RDEPENDS:${PN}:remove = "nativesdk-unfs3 \
    "
