RDEPENDS:packagegroup-base:append = " \
    packagegroup-entropy-daemon \
"
