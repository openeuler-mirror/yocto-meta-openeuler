### now, no gdb-cross-canadian in external toolchain

GDB:tcmode-external = ""
