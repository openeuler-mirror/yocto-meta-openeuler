require gettext-openeuler-src.inc
