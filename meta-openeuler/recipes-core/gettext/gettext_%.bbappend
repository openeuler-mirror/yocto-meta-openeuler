require gettext-openeuler-src.inc

ASSUME_PROVIDE_PKGS = "gettext"
