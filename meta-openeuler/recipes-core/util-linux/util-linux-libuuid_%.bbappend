require util-linux-src.inc

# code is the same with util-linux
OPENEULER_REPO_NAME = "util-linux"
