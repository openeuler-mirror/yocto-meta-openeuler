include timezone-append.inc
# openeuler tzdata patches lack Upstream-Status headers and apply with fuzz;
# INSANE_SKIP does not suppress do_qa_patch errors, only do_package_qa.
