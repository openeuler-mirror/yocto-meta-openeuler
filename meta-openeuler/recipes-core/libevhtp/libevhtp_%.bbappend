
SRC_URI_prepend = "file://0006-libevhtp-add-gcov-compile-options.patch \
"