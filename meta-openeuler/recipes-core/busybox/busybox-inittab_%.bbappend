# main yocto-poky/meta/recipes-core/busybox/busybox-inittab_1.33.2.bb
# we create this file as a layer to use openeuler's configs files

FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"
