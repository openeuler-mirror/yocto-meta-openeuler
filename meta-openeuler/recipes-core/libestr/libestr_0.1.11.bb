SUMMARY = "some essentials for string handling (and a bit more)"
HOMEPAGE = "http://libestr.adiscon.com/"
LICENSE = "LGPLv2.1"
LIC_FILES_CHKSUM = "file://COPYING;md5=9d6c993486c18262afba4ca5bcb894d0"

UPSTREAM_CHECK_URI = "http://libestr.adiscon.com/download/"
SRC_URI = "file://${BPN}/${BP}.tar.gz"
inherit autotools
