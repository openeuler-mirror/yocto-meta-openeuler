SRC_URI = " \
    file://${BP}.tar.gz \
"
