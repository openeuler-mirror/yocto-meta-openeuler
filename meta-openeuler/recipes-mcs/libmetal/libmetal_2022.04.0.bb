require libmetal.inc

SRC_URI_prepend = "file://libmetal-add-additional-arches.patch \
"
