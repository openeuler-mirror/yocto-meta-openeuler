require openamp.inc

# In openeamp demo, we use screen to open pty shell
RDEPENDS_${PN} += "screen"
