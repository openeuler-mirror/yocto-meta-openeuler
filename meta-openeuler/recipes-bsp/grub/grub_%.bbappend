# main bbfile: yocto-poky/meta/recipes-bsp/grub/grub_git.bb
require grub-source-openeuler.inc

ASSUME_PROVIDE_PKGS = "grub2-common grub2-tools grub2-tools-minimal"
