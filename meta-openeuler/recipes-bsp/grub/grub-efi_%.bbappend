# main bbfile: yocto-poky/meta/recipes-bsp/grub/grub-efi_git.bb
require grub-source-openeuler.inc
