# Upstream recipe: yocto-poky/meta/recipes-bsp/lrzsz/lrzsz_0.12.20.bb
# Source: https://atomgit.com/src-openeuler/lrzsz (0.12.20, tarball is bit-identical to upstream)
SRC_URI:prepend = " \
    file://${BP}.tar.gz \
"
