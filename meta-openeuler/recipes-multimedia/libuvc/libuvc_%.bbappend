# ref: yocto-meta-openembedded/meta-multimedia/recipes-multimedia/libuvc/libuvc.bb

PV = "v0.0.7"

inherit openeuler_source

S = "${WORKDIR}/git"
