OPENEULER_REPO_NAME = "alsa-lib"

PV = "1.2.5.1"

SRC_URI[sha256sum] = "f7c5bae1545abcd73824bc97f4e72c340e11abea188ba0f1c06f5e0ad776b179"
