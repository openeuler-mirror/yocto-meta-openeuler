# the main bb file: yocto-poky/meta/recipes-multimedia/libogg/libogg_1.3.5.bb

PV = "1.3.5"

SRC_URI:prepend = "file://${BP}.tar.xz"

SRC_URI[md5sum] = "3178c98341559657a15b185bf5d700a5"
SRC_URI[sha256sum] = "c4d91be36fc8e54deae7575241e03f4211eb102afb3fc0775fbbc1b740016705"
