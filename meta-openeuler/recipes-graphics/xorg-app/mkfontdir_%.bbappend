require openeuler-xorg-app-common.inc

OPENEULER_LOCAL_NAME = "xorg-x11-font-utils"

PV = "1.0.7"
