PV = "0.4.0"

SRC_URI:prepend = "file://${BPN}-${PV}.tar.bz2 \
"
