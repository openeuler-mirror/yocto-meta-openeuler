require openeuler-xorg-lib-common.inc

PV = "1.5.5"

# the src repo switched the tarball to xz with this release
XORG_EXT = "tar.xz"

SRC_URI[sha256sum] = "3ad316c1781fe2fe22574b819e81f0eff087a8560377f521ba932238b41b251f"
