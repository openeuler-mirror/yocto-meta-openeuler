require openeuler-xorg-lib-common.inc

PV = "6.0.1"

LIC_FILES_CHKSUM = "file://COPYING;md5=a5a9755c8921cc7dc08a5cfe4267d0ff"
