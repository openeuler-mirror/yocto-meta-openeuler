require openeuler-xorg-lib-common.inc

PV = "1.1.6"

SRC_URI[sha256sum] = "2afcc139eb6eb926ffe344494b1fc023da25def42874496e6e6d3aa8acef8595"
