require openeuler-xorg-lib-common.inc

PV = "1.2.2"

XORG_EXT = "tar.xz"
