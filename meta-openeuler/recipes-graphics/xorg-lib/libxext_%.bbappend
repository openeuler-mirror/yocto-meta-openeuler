require openeuler-xorg-lib-common.inc

PV = "1.3.5"

LIC_FILES_CHKSUM = "file://COPYING;md5=4234bb3b2f1521ea101e4e9db7c33c69"

SRC_URI[sha256sum] = "1a3dcda154f803be0285b46c9338515804b874b5ccc7a2b769ab7fd76f1035bd"
