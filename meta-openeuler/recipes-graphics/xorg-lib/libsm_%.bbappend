require openeuler-xorg-lib-common.inc

PV = "1.2.4"

SRC_URI[sha256sum] = "51464ce1abce323d5b6707ceecf8468617106e1a8a98522f8342db06fd024c15"
