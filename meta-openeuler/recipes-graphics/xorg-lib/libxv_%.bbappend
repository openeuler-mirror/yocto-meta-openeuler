require openeuler-xorg-lib-common.inc

PV = "1.0.12"

