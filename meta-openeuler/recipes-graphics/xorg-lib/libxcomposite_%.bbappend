require openeuler-xorg-lib-common.inc

PV = "0.4.6"

SRC_URI[sha256sum] = "3599dfcd96cd48d45e6aeb08578aa27636fa903f480f880c863622c2b352d076"
