require openeuler-xorg-lib-common.inc

PV = "2.3.8"

SRC_URI[sha256sum] = "75b4378644f5df3a15f684f8f0b5ff1324d37aacd5a381f3b830a2fbe985f660"
