PV = "0.4.1"

SRC_URI:prepend = "file://${BPN}-${PV}.tar.bz2 \
"
