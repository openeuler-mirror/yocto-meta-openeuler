require openeuler-xorg-lib-common.inc

PV = "2.0.6"
