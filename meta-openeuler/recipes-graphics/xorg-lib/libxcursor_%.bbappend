require openeuler-xorg-lib-common.inc

PV = "1.2.1"

# License update
LIC_FILES_CHKSUM = "file://COPYING;md5=dbf3bd0f2348eeccd0f217146ba26250"

SRC_URI[sha256sum] = "77f96b9ad0a3c422cfa826afabaf1e02b9bfbfc8908c5fa1a45094faad074b98"
