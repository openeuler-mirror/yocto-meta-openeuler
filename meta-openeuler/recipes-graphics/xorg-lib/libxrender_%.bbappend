require openeuler-xorg-lib-common.inc

PV = "0.9.11"

SRC_URI[sha256sum] = "6aec3ca02e4273a8cbabf811ff22106f641438eb194a12c0ae93c7e08474b667"
