require openeuler-xorg-lib-common.inc

PV = "1.3.2"

SRC_URI[sha256sum] = "e93a85099604beb244ee756dcaf70e18b08701c1ca84c4de0126cd71bd6c8181"
