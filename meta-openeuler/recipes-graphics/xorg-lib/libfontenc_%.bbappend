require openeuler-xorg-lib-common.inc

PV = "1.1.7"
