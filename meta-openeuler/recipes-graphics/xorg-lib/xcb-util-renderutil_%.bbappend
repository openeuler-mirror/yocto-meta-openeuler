PV =  "0.3.9"

SRC_URI += " \
        file://${BPN}-${PV}.tar.bz2 \
        file://backport-0001-Update-configure.ac-bug-URL-for-gitlab-migration.patch \
"
