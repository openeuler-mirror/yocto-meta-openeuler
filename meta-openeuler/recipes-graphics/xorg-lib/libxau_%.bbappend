require openeuler-xorg-lib-common.inc

PV = "1.0.10"

SRC_URI[sha256sum] = "51a54da42475d4572a0b59979ec107c27dacf6c687c2b7b04e5cf989a7c7e60c"
