require openeuler-xorg-lib-common.inc

XORG_EXT = "tar.xz"

PV = "1.8.1"

SRC_URI[md5sum] = "74055672a111a98ce2841d2ec4057b05"
SRC_URI[sha256sum] = "2ed181446a61c7337576467870bc5336fc9e222a281122d96c4d39a3298bba00"
