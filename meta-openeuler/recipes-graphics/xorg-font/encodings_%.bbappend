require openeuler-xorg-font-common.inc

OPENEULER_LOCAL_NAME = "xorg-x11-fonts"

PV = "1.0.5"
