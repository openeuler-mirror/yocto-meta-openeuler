ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-generators-native \
"

FILES_${PN} += "/usr/share"
