ROS_EXEC_DEPENDS:remove += "yaml-cpp"
ROS_EXPORT_DEPENDS:remove += "yaml-cpp"
