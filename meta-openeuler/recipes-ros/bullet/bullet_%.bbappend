inherit openeuler_ros_source

