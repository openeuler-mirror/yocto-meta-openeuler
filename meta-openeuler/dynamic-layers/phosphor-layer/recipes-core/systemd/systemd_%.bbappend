# remove the patches which cause errors in the build
SRC_URI:remove = "file://0001-sd-bus-Don-t-automatically-add-ObjectManager.patch"
