# nerdctl is a docker-style container engine
# set BUILD_GIT_NERDCTL to non-empty
# NOTICE: building nerdctl takes amazing time
# it's recommended to install nerdctl binary manually actually,
# recommended version is 2.0+
BUILD_GIT_NERDCTL = ""
