# still depend gnu's binutils like as/elfedit(for kernel build) ld(normally compile).
binutils_binaries = "llvm-ar as ld ld.bfd ld.gold elfedit llvm-nm llvm-objcopy llvm-objdump llvm-ranlib llvm-strip \
                     llvm-addr2line llvm-cxxfilt llvm-readelf llvm-size llvm-strings"
