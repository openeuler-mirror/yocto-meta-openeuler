CFLAGS:append:toolchain-clang = " -Wno-error=incompatible-pointer-types-discards-qualifiers "
