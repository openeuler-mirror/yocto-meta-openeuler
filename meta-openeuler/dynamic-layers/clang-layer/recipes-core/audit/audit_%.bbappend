CFLAGS:append:toolchain-clang = " -Wno-implicit-function-declaration "
