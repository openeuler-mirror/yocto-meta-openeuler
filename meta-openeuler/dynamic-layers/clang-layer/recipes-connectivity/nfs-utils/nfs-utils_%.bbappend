CFLAGS:append = " -Wno-error=strict-prototypes -Wno-error=logical-not-parentheses "
