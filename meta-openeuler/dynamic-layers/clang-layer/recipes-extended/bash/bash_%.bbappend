CFLAGS:append:toolchain-clang = " -Wno-return-type "
CXXFLAGS:append:toolchain-clang = " -Wno-return-type "