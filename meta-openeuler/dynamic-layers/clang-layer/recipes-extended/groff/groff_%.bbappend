CC:append:toolchain-clang = " -Wno-error=register "
CXX:append:toolchain-clang = " -Wno-error=register "
