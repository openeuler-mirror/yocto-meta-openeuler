TOOLCHAIN = "clang"

HOST_CC_ARCH:append = " -Wno-error=unused-command-line-argument "
