CFLAGS:append:toolchain-clang = " -Wno-error=incompatible-function-pointer-types -Wno-error=implicit-function-declaration "
