CFLAGS:append:toolchain-clang = " -Wno-error=implicit-function-declaration "
CXXFLAGS:append:toolchain-clang = " -Wno-error=implicit-function-declaration "
