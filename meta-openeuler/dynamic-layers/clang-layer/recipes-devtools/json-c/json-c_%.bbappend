CFLAGS:append = " -Wno-error=strict-prototypes "
