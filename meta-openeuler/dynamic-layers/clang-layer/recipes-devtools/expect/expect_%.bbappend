CFLAGS:append:toolchain-clang = " -Wno-error=implicit-function-declaration "
