CFLAGS:append:toolchain-clang = " -Wno-error=enum-constexpr-conversion "
CXXFLAGS:append:toolchain-clang = " -Wno-error=enum-constexpr-conversion "
