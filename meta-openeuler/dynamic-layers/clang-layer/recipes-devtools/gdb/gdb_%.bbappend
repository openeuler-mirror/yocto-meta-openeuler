CC:append:toolchain-clang = " -Wno-error=enum-constexpr-conversion "
CXX:append:toolchain-clang = " -Wno-error=enum-constexpr-conversion "
