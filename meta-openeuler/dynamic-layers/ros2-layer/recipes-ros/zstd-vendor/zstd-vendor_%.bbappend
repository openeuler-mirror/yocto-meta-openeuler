FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"

LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=13;md5=496ab866bb705dc664bdce6d58d9e3fc"
