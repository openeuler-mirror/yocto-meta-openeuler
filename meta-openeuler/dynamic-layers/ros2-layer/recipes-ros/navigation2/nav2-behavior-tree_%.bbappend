include less-warning.inc

