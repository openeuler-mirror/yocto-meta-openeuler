OPENEULER_LOCAL_NAME = "navigation2"

SRC_URI:append = " \
        file://ros-humble-nav2-behaviors-1.1.9-fix-gcc12-error.patch \
        "
