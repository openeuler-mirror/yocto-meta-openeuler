# not need rviz for runtime
ROS_EXEC_DEPENDS:remove = " nav2-rviz-plugins "
