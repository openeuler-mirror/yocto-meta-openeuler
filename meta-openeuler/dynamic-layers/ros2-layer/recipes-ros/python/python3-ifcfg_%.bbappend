PV = "0.23"
SRC_URI[md5sum] = "b26bdcf553dee44c0e491fb15a3fec91"
SRC_URI[sha256sum] = "624b5ac541693ccd3e2cecc348c0e88154ded4aaadd254cb231212dfaafdbd02"
require pypi-src-openeuler.inc
