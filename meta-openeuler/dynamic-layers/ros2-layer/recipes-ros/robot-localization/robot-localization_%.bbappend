inherit openeuler_source oee-archive
