DEPENDS:remove = "libglu"

ROS_BUILD_DEPENDS = " \
    libeigen \
    suitesparse \
"

ROS_EXEC_DEPENDS = " \
    libeigen \
    suitesparse \
"
