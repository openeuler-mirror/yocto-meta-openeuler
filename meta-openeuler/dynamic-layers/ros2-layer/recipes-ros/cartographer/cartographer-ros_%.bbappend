SRC_URI:append = " \
        file://cartographer-ros-fix-multiple-definition-error.patch \
        file://cartographer-ros-fix-absl.patch \
        file://cartographer-ros-adapt-glog-0.6.0.patch \
        "
