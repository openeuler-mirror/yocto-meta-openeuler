require suitesparse-openeuler.inc

S = "${WORKDIR}/SuiteSparse-${SUITESPARSE_PV}/metis-5.1.0"
