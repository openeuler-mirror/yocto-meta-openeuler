require suitesparse-openeuler.inc
