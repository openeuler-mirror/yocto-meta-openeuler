require suitesparse-openeuler.inc

S = "${WORKDIR}/SuiteSparse-${PV}/CAMD"
