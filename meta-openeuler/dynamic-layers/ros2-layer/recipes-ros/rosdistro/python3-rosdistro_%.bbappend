inherit openeuler_source

SRC_URI:append = "file://0-test-index-increase-http-server-startup-wait-time.patch \
"
