inherit openeuler_source

