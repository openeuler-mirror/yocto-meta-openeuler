FILES:${PN} += "/usr/share /usr/lib"

