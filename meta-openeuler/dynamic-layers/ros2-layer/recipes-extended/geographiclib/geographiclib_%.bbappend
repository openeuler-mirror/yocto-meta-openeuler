inherit openeuler_source            

S = "${WORKDIR}/GeographicLib-1.48"
