SRC_URI:prepend = " file://${BP}.tar.bz2 "
