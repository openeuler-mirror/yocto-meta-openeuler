# pointercal does not require code download, to avoid the conflict of pointercal folder
# (set by DL_DIR ?= "${OPENEULER_SP_DIR}/${BPN}" )
# and pointercal script file (with pointercal_0.0.bb ),
OPENEULER_REPO_NAME = "pointercal_dummy"
