PV = "9.9.0"

SRC_URI:prepend = " \
    file://${BP}.tar.gz \
"
