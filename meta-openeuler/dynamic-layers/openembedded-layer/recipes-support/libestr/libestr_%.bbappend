# the main bb file: yocto-meta-openembedded/meta-oe/recipes-support/libestr/libestr_0.1.11.bb

SRC_URI = "file://${BP}.tar.gz \
"