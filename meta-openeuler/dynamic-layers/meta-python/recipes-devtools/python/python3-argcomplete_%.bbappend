PV = "2.0.0"
SRC_URI[sha256sum] = "347d2ac6075083923b6f5bccc49b589983f236dc64f6ee855e1ca28538006386"
require pypi-src-openeuler.inc
OPENEULER_REPO_NAME = "python-argcomplete"
OPENEULER_LOCAL_NAME = "python-argcomplete"
