PV = "8.0.4"
require pypi-src-openeuler.inc

SRC_URI[md5sum] = "c89efc98d1b36d52ba26a39c803df0cc"
SRC_URI[sha256sum] = "8458d7b1287c5fb128c90e23381cf99dcde74beaf6c7ff6384ce84d6fe090adb"
