PV = "4.0.3"
SRC_URI[md5sum] = "aa1da7f967fc9a23b8f2ef76b9793065"
SRC_URI[sha256sum] = "7d3fbbde18228f4ff2f1f119a45cdffa458b4c0dee32eb4d2bb2f82554bac7bc"
require pypi-src-openeuler.inc
