PV = "2.8.2"
SRC_URI[md5sum] = "5970010bb72452344df3d76a10281b65"
SRC_URI[sha256sum] = "0123cacc1627ae19ddf3c27a5de5bd67ee4586fbdd6440d9748f8abb483d3e86"
require pypi-src-openeuler.inc
OPENEULER_REPO_NAME = "${PYPI_PACKAGE}"
