PV = "3.1.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=690c2d09203dc9e07c4083fc45ea981f"
require pypi-src-openeuler.inc
OPENEULER_REPO_NAME = "pyflakes"
