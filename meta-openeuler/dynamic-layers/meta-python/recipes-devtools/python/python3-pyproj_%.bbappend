PV = "3.6.1"

# repo name containes "python3"
require pypi-src-openeuler.inc
