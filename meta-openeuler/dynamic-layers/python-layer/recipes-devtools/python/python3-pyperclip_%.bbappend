PV = "1.8.2"
SRC_URI[md5sum] = "853603b2e8fa1b13622fdbe72d1fb201"
SRC_URI[sha256sum] = "105254a8b04934f0bc84e9c24eb360a591aaf6535c9def5f29d92af107a9bf57"
require pypi-src-openeuler.inc
