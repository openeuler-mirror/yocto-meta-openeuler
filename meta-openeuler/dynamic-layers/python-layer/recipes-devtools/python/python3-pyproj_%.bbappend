PV = "3.7.0"

# repo name containes "python3"
require pypi-src-openeuler.inc
