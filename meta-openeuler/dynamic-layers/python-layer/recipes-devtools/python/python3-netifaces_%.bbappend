PV = "0.11.0"
SRC_URI[md5sum] = "3146dcb3297dd018ae5eb9a52b440419"
SRC_URI[sha256sum] = "043a79146eb2907edf439899f262b3dfe41717d34124298ed281139a8b93ca32"
require pypi-src-openeuler.inc
