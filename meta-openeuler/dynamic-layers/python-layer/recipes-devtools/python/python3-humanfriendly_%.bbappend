PV = "3.11.6"
require pypi-src-openeuler.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=5d178009f806c2bdd498a19be0013a7a"
