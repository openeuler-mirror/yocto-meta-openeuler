require qt5-src.inc

SRC_URI:prepend = "file://qtlocation-gcc10.patch \
           "
