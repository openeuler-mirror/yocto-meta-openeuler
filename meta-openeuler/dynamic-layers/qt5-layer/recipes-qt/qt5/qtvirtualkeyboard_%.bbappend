require qt5-src.inc

