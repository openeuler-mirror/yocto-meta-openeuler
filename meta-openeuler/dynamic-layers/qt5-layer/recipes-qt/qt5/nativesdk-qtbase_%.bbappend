require qt5-src.inc
require qtbase-src.inc

# License update
LIC_FILES_CHKSUM:remove = "file://LICENSE.QT-LICENSE-AGREEMENT;md5=c8b6dd132d52c6e5a545df07a4e3e283"
LIC_FILES_CHKSUM:prepend = "file://LICENSE.QT-LICENSE-AGREEMENT;md5=38de3b110ade3b6ee2f0b6a95ab16f1a \
"
