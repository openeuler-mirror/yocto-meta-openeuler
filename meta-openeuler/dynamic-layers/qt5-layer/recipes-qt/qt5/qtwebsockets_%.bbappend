require qt5-src.inc

SRC_URI:prepend = "file://qt5-qtwebsockets-gcc11.patch \
           "
