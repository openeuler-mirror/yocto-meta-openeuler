RDEPENDS_packagegroup-base-extended_append = " \
weston \
qtwayland \
qtbase \
kmscube \
qt5-opengles2-test \
helloworld-gui \
"
