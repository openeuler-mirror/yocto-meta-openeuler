require openeuler-qt.inc
