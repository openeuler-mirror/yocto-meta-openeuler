require libtool-src.inc
