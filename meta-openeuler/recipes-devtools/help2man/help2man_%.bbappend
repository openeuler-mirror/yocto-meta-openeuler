
PV = "1.49.3"

SRC_URI:prepend = "file://help2man-${PV}.tar.xz \
"
