PV = "20230828-3.1"

SRC_URI:prepend = " \
    file://${BPN}-${PV}.tar.gz \
"

