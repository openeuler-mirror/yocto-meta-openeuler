PV = "1.5.1"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b5cda97fbd7959ad47a952651a87051a"
SRC_URI[md5sum] = "f7a5271af9b81246fbdf57d703afce2f"
SRC_URI[sha256sum] = "13ae38502be632115abf8a24cbe5f4da52e3b5231990aff31123c805306ccb9c"
require pypi-src-openeuler.inc
