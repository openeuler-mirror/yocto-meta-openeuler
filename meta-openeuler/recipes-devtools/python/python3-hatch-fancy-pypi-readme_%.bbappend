PV = "24.1.0"
require pypi-src-openeuler.inc

SRC_URI[md5sum] = "f5f9e639f066c91f8e623ec6231beae9"
SRC_URI[sha256sum] = "44dd239f1a779b9dcf8ebc9401a611fd7f7e3e14578dcf22c265dfaf7c1514b8"
