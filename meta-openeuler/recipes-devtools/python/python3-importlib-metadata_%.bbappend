PV = "4.12.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"
SRC_URI[md5sum] = "cfcf29185e13439c76d09c94bc8d81f4"
SRC_URI[sha256sum] = "637245b8bab2b6502fcbc752cc4b7a6f6243bb02b31c5c26156ad103d3d45670"
require pypi-src-openeuler.inc
OPENEULER_REPO_NAME = "python-importlib-metadata"
