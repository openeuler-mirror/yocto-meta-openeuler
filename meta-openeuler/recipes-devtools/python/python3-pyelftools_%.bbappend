PV = "0.29"
require pypi-src-openeuler.inc
OPENEULER_REPO_NAME = "${PYPI_PACKAGE}"
