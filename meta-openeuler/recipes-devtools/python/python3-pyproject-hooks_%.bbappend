PV = "1.0.0"

SRC_URI[md5sum] = "69b0b6de189bc04c3f9e304281765741"
SRC_URI[sha256sum] = "f271b298b97f5955d53fb12b72c1fb1948c22c1a6b70b315c54cedaca0264ef5"

require pypi-src-openeuler.inc
