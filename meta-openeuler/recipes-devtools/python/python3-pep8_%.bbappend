require pypi-src-openeuler.inc

# latest commit of branch Multi-Version_OpenStack-Train_openEuler-22.03-LTS-SP3
PV = "1.5.7"
LIC_FILES_CHKSUM = "file://README.rst;md5=7c91dbdbf7e4eb3603e9b6c94bf2aa7f"
SRC_URI[md5sum] = "f6adbdd69365ecca20513c709f9b7c93"
SRC_URI[sha256sum] = "15b42131b25f376165d195fe4e17b0a28311182aaf9330d5eb575bbeda5a6989"
