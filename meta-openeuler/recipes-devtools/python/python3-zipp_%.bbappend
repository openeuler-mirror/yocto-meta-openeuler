PV = "3.10.0"
SRC_URI[md5sum] = "5a1fc692b57b348d1e259484b405ddf6"
SRC_URI[sha256sum] = "9f50f446828eb9d45b267433fd3e9da8d801f614129124863f9c51ebceafb87d"
require pypi-src-openeuler.inc
SRC_URI += "file://0001-add-setup.py.patch "
