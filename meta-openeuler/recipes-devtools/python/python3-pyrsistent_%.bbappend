OPENEULER_LOCAL_NAME = "python-${PYPI_PACKAGE}"

SRC_URI = "file://pyrsistent-${PV}.tar.gz "
