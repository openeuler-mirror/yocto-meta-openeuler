# Upstream recipe: yocto-poky/meta/recipes-devtools/python/python3-editables_0.3.bb
# Source: https://atomgit.com/src-openeuler/python-editables
# Pinned at 0.3 (openEuler-23.09 branch head), the same version as the
# upstream recipe; the tarball is bit-identical to the pypi sdist, so the
# recipe's checksums and LIC_FILES_CHKSUM stay valid
require pypi-src-openeuler.inc
