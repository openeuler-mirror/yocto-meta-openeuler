PV = "5.0.1"

require pypi-src-openeuler.inc
