require pypi-src-openeuler.inc

OPENEULER_LOCAL_NAME = "python-markupsafe"

PV = "2.1.3"

SRC_URI[sha256sum] = "af598ed32d6ae86f1b747b82783958b1a4ab8f617b06fe68795c7f026abbdcad"
