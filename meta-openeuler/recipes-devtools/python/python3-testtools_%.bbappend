PV = "2.6.0"

require pypi-src-openeuler.inc
