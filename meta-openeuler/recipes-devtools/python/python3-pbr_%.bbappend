PV = "6.0.0"

require pypi-src-openeuler.inc
OPENEULER_REPO_NAME = "python-pbr"

SRC_URI[sha256sum] = "d1377122a5a00e2f940ee482999518efe16d745d423a670c27773dfbc3c9a7d9"
