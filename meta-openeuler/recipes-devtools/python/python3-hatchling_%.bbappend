PV = "1.27.0"
require pypi-src-openeuler.inc

SRC_URI[sha256sum] = "971c296d9819abb3811112fc52c7a9751c8d381898f36533bb16f9791e941fd6"
DEPENDS += "python3-trove-classifiers-native"
