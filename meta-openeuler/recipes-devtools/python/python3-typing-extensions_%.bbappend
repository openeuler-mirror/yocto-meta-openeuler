PV = "3.11.6"
require pypi-src-openeuler.inc
OPENEULER_LOCAL_NAME = "python-typing-extensions"
