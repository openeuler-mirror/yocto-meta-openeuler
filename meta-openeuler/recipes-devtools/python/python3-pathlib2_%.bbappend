PV = "2.3.7"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=2dc08586cce3ab91bfa091b655c0e440"
SRC_URI[md5sum] = "ff87562935872cf68f935f8a9e43f84f"
SRC_URI[sha256sum] = "7a4329d67beff9a712e1d3ae147e4e3e108b0bfd284ffdea03a635126c76b3c0"
require pypi-src-openeuler.inc
