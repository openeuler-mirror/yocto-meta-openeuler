require pypi-src-openeuler.inc

SRC_URI:append = "file://backport-CVE-2024-3651.patch \
"
