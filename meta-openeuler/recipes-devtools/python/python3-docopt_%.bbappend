PV = "0.6.2"
require pypi-src-openeuler.inc
