PV = "8.12.0"
SRC_URI[md5sum] = "5cdaf7f40f1e7d1c9ba887e7765db596"
SRC_URI[sha256sum] = "b708a64c95508d4f1fef137acbe3b482b6a95d0cd1b54400c50534cb0ae05923"
require pypi-src-openeuler.inc

