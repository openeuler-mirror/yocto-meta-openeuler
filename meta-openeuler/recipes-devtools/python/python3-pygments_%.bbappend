require pypi-src-openeuler.inc

PV = "3.11.6"
