PV = "0.12.0"
SRC_URI[md5sum] = "422882c3cb61657d8c64738a2a886c3d"
SRC_URI[sha256sum] = "15967db1f1214013dca65b1180745047b9be457d73da224fcda3d9dd4e96a138"
require pypi-src-openeuler.inc
