PV = "1.0.0"

require pypi-src-openeuler.inc
