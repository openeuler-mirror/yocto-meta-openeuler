require pypi-src-openeuler.inc

SRC_URI:remove = "${PYPI_SRC_URI}"

