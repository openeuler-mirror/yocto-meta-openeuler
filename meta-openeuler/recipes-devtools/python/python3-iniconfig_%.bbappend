# Upstream recipe: yocto-poky/meta/recipes-devtools/python/python3-iniconfig_2.0.0.bb
# Source: https://atomgit.com/src-openeuler/python-iniconfig
# Pinned at 2.0.0 (openEuler-23.09/24.03/25.03 branch head), the same version
# as the upstream recipe; the tarball is bit-identical to the pypi sdist, so
# the recipe's checksums and LIC_FILES_CHKSUM stay valid
require pypi-src-openeuler.inc
