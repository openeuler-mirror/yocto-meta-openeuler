PV = "3.11.6"
SRC_URI[sha256sum] = "8c85c2876142a764e5b7548e7d9a0e0ddb46f5185161049a79b7e974454223be"
require pypi-src-openeuler.inc
