PV = "0.68"

# openeuler src
SRC_URI:prepend = " \
    file://${BP}.tar.gz \
"

SRC_URI[sha256sum] = "fe8c09de03c106e85b3737c8f03ade147c956b79ed7af485a1c8a3858db38426"
