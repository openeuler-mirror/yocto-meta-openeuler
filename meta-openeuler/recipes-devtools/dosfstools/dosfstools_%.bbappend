SRC_URI:prepend= " file://${BP}.tar.gz \
      file://0001-Fix-vasprintf-implementation.patch \
"
