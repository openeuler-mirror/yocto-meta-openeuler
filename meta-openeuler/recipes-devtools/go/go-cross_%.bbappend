require go-openeuler-common.inc

