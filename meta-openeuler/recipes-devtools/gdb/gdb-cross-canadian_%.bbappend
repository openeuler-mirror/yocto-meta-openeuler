require gdb-src.inc

# keep same with upstream
DEPENDS += "nativesdk-mpfr"
