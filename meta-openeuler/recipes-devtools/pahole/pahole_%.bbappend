# bbfile: yocto-meta-openembedded/meta-oe/recipes-devtools/pahole/pahole_1.22.bb

PV = "1.28"
SRCREV = "1cb4202ed2cbd591734f6b7fb1d2b8aa8eb5a1c3"
SRC_URI = "file://dwarves-${PV}.tar.xz \
"

S = "${WORKDIR}/dwarves-${PV}"
