inherit gettext
require m4_src.inc
