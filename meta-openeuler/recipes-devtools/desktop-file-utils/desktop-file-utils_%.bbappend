PV = "0.28"

SRC_URI:prepend = " \
    file://${BP}.tar.xz \
"
