SRC_URI += " \
        file://${BP}.tar.xz \
        file://fix-fixxref-not-found-file.patch \
        file://fix-mkdb-not-found-file.patch \
        file://fix-gtkdoc-rebase-NoneType-object-has-no-attribute-group.patch \
        "
