OPENEULER_LOCAL_NAME = "gnome-themes-standard"

SRC_URI = " \
    file://${BP}.tar.xz \
"
