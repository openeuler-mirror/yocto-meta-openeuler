PV = "4.8.1"
PR = "r1"

# no base-passwd now in openeuler
DEPENDS_remove += "base-passwd"
