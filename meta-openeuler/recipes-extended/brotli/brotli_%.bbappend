PV = "1.1.0"

SRC_URI = " \
    file://v${PV}.tar.gz \
"

S = "${WORKDIR}/brotli-${PV}"

