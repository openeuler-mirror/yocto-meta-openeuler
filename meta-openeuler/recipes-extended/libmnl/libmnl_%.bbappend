# main bbfile: meta/recipes-extended/libmnl/libmnl_1.0.4.bb

PV = "1.0.5"

SRC_URI = " \
    file://libmnl-${PV}.tar.bz2;name=tar \
"

SRC_URI[tar.md5sum] = "0bbb70573119ec5d49435114583e7a49"
SRC_URI[tar.sha256sum] = "274b9b919ef3152bfb3da3a13c950dd60d6e2bcd54230ffeca298d03b40d0525"
