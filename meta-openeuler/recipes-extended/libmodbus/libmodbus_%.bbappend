PV = "3.1.6"
OPENEULER_BRANCH = "master"

SRC_URI += "file://0000-libmodbus-Heap-based-Buffer-Overflow-in-modbus_reply.patch"

SRC_URI[md5sum] = "15c84c1f7fb49502b3efaaa668cfd25e"
SRC_URI[sha256sum] = "d7d9fa94a16edb094e5fdf5d87ae17a0dc3f3e3d687fead81835d9572cf87c16"
