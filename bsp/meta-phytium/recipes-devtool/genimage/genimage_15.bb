require genimage.inc

SRC_URI[sha256sum] = "9bca24bf883310b30ee4511cbc3a580e40ad4540826e5ed3992c595ce72d003e"
