require recipes-kernel/linux/linux-phytium.inc

# add COMPATIBLE_MACHINE
COMPATIBLE_MACHINE = "phytium"
