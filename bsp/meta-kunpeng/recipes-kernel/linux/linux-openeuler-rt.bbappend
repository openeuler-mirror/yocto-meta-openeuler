require recipes-kernel/linux/linux-kp920.inc

SRC_URI += "file://cfg-fragments/rt.cfg"
