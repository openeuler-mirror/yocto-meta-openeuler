require recipes-kernel/linux/linux-kp920.inc

# add COMPATIBLE_MACHINE
COMPATIBLE_MACHINE = "kp920"
