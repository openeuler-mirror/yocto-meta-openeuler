PACKAGES:remove = "\
    packagegroup-k3s-host \
    packagegroup-k3s-node \
    "
