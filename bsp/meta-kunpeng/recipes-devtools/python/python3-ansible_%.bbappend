# Install all modules except windows
ANSIBLE_WHITELIST_MODULES = "cloud clustering commands crypto database files identity inventory \
    list messaging monitoring net_tools network notification packaging __pycache__ remote_management \
    source_control storage system utilities web_infrastructure"
