# for amd libdrm driver
RDEPENDS:${PN} += " libdrm-radeon linux-firmware-radeon "
