do_image[depends] += " deploy-bootfiles:do_deploy"
