require recipes-kernel/linux/linux-visionfive2.inc

COMPATIBLE_MACHINE = "starfive-dubhe"
