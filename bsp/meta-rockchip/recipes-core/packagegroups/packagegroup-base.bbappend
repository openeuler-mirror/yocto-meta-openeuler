RDEPENDS:packagegroup-base:append = " \
e2fsprogs-resize2fs \
wpa-supplicant \
wififirmware \
"
