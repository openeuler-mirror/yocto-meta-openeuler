require recipes-kernel/linux/linux-sd3403.inc

COMPATIBLE_MACHINE = "sd3403"
