# adapted for hi1711
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-mcs_km-adapted-for-hi3093.patch"
