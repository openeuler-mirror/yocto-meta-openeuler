require recipes-core/images/bsp-${MACHINE}.inc
