# we add bootfile
RDEPENDS_${PN} += " \
    bootfile \
    3093-watchdog \
"
