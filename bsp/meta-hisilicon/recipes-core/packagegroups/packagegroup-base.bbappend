RDEPENDS_packagegroup-base_append += " \
e2fsprogs-resize2fs \
"
