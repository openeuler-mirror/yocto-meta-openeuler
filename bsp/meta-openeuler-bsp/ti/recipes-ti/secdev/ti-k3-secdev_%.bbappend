OPENEULER_REPO_NAME = "core-secdev-k3"
SRC_URI = "file://core-secdev-k3"
S = "${WORKDIR}/core-secdev-k3"
