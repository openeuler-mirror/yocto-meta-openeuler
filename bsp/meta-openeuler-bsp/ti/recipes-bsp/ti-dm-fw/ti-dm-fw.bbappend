OPENEULER_LOCAL_NAME = "ti-linux-firmware"
SRC_URI = "file://ti-linux-firmware"
S = "${WORKDIR}/ti-linux-firmware"
