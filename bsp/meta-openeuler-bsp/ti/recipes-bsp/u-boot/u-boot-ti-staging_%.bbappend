OPENEULER_REPO_NAME = "myir-ti-uboot"

SRCPV = ""

SRC_URI = "file://myir-ti-uboot"

S = "${WORKDIR}/myir-ti-uboot"

CREATE_SRCIPK:k3 = "0"
