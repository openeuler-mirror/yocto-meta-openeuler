RDEPENDS:packagegroup-base:append = " \
wpa-supplicant \
${NIC_MODEL_FIRMWARE} \
"
