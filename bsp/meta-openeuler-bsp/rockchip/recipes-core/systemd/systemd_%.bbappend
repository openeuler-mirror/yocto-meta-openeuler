# remove 0001-basic-Allow-unknown-filesystems.patch seems it`s already fix
SRC_URI_remove = " \
	file://0001-basic-Allow-unknown-filesystems.patch \
"
