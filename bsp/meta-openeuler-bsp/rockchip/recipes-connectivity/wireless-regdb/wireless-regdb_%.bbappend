
FILES_${PN}-static_append = "${nonarch_libdir}/crda/regulatory.bin"
