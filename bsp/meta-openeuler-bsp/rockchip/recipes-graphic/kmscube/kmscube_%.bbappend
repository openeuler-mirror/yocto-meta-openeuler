# get src from here
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://rockchip_libmali_only_support_gl2ext.patch "
