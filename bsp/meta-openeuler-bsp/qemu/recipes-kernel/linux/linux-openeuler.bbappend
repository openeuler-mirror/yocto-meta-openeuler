require recipes-kernel/linux/linux-${MACHINE}.inc
