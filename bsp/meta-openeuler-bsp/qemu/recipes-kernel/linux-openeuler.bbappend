include recipes-kernel/linux/linux-${MACHINE}.inc
