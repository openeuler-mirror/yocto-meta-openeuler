require recipes-kernel/linux/linux-sunxi.inc

# add COMPATIBLE_MACHINE
COMPATIBLE_MACHINE = "oka40i"
