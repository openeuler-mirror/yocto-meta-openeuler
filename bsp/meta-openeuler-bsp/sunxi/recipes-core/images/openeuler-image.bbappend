inherit features_check

CONFLICT_DISTRO_FEATURES = " dsoftbus isulad "
