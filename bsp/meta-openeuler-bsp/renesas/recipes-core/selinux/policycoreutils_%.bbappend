SRC_URI:remove = " \
        file://fix-fixfiles-N-date-function.patch;patchdir=.. \
        file://fix-fixfiles-N-date-function-two.patch;patchdir=.. \
"
