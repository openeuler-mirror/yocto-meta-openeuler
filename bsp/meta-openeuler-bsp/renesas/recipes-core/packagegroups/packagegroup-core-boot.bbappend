require recipes-core/packagegroups/${MACHINE}.inc
