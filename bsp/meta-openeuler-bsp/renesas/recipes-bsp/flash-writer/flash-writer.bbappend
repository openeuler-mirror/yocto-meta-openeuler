require recipes-bsp/flash-writer/${MACHINE}.inc