RDEPENDS:${PN}:remove = " \
    kernel-img \
"