#bbfile: yocto-meta-renesas/recipes-bsp/flash-writer/flash-writer.bb

OPENEULER_LOCAL_NAME = "myir-renesas-flash-writer"
