CXXFLAGS:append:toolchain-clang = " -Wno-error=inused-lambda-capture "
EXTRA_OEMESON:append:toolchain-clang = " -Dwerror=false "
