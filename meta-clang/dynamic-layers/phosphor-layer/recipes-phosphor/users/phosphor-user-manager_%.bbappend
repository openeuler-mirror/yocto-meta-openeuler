CXX:append:toolchain-clang = " -Wno-error=pessimizing-move -Wno-error=inconsistent-missing-override -Wno-error=unused-const-variable -Wno-error=defaulted-function-deleted "
EXTRA_OEMESON:append:toolchain-clang = " -Dwerror=false "
