CXXFLAGS:append:toolchain-clang = " -Wno-error=unsafe-buffer-usage "
EXTRA_OEMESON:append:toolchain-clang = " -Dwerror=false "
