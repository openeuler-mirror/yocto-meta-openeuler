CXXFLAGS:append:toolchain-clang = " -Wno-error=defaulted-function-deleted "
EXTRA_OEMESON:append:toolchain-clang = " -Dwerror=false "
