CFLAGS:append:toolchain-clang = " -Wno-error=defaulted-function-deleted "
CXXFLAGS:append:toolchain-clang = " -Wno-error=defaulted-function-deleted "
